# Keil uVision project Quick_Start.uvprojx, settings and files
target Quick_Start (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Quick_Start +hex
  AfterMake: fromelf -c -v -a --output=@P.asm Objects\%L
  AfterMake: fromelf --bin --output=@P.bin Objects\%L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\ELF2_BSP;..\..\..\ELF2_BSP\CMSIS\Core\Include;..\..\..\ELF2_BSP\Debug;..\..\..\ELF2_BSP\Debug\RTT;..\..\..\ELF2_BSP\Driver;..\..\..\ELF2_BSP\Driver\regmap;..\..\..\ELF2_BSP\Device\ELF2\Include;..\..\..\ELF2_BSP\Device\ELF2\Source\ARM
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\elf2_example.sct
  link misc: --keep=int_register.o(int_callback_area)
  group user
    ./src/: main.c uart_demo.c timer_demo.c exti_demo.c pulse_demo.c
    ../../../ELF2_BSP/Driver/: int_register.c intc.c
  group startup
    ../../../ELF2_BSP/Device/ELF2/Source/ARM/: startup_elf2.s
    ../../../ELF2_BSP/Device/ELF2/Source/: system_elf2.c
  group lib
    ../../../ELF2_BSP/Driver/: ELF2_CM3_Lib.lib
  group log
    ../../../ELF2_BSP/Debug/: log.c debug.c
    ../../../ELF2_BSP/Debug/RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
